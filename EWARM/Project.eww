<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Internal_and_External_Rtc.ewp</path>
  </project>
  <batchBuild />
</workspace>
